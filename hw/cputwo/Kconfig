## hw/cputwo/Kconfig
```kconfig
config CPUTWO_BOARD
    bool
    default y
    depends on CPUTWO
    select UNIMP
```
